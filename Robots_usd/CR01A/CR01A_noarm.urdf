Commit message: 20250508

File: Robots_usd/CR01A/CR01A_noarm.urdf (robot description, URDF)
Before this commit: robot CR01A, 13 links, 12 joints
Joints:
- joint left_hip_pitch_joint: origin xyz=0 0.161900000000006 0 rpy=0 0 0 -> xyz=0 0.161900000000006 0.0 rpy=0 0 0
