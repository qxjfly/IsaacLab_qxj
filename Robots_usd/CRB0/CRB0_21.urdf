Commit message: 20250710_BS

File: Robots_usd/CRB0/CRB0_21.urdf (robot description, URDF)
Before this commit: robot CR01B, 30 links, 29 joints
Links:
- link waist_roll_link: mass 1.40004 -> 1.000
Joints:
- joint left_hip_pitch_joint: origin xyz=0 0.162 0 rpy=0 0 0 -> xyz=0 0.162 0.0 rpy=0 0 0
